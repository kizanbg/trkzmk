## config/boards/shields/trk/Kconfig.defconfig
```kconfig
if SHIELD_trk

config ZMK_KEYBOARD_NAME
    default "trkbt"

config PWM
    default y

config LED_PWM
    default y

endif
```
